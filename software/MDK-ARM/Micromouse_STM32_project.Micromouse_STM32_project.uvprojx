# Keil uVision project Micromouse_STM32_project.Micromouse_STM32_project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Micromouse_STM32_project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER __EVAL __MICROLIB
  c include: ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Inc
  asm define: __EVAL
  library: MicroLIB
  memory RVCT4: RAM 0x8000000 size 0x40000
  memory RVCT9: ROM 0x20000000 size 0x10000
  scatter file: ./Micromouse_STM32_project.Micromouse_STM32_project.sct
  link misc: --entry=Reset_Handler --info summarysizes --load_addr_map_info --summary_stderr
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User
    ../Src/: Motors.c Sensors.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c Uart.c
    ../Inc/: Motors.h Sensors.h Uart.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 5.4.0
